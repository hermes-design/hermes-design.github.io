options:
  parameters:
    generate_options: qt_gui
    id: attackerv
    output_language: python
    title: Attacker with Periodic Cycle
  states: {}

blocks:
- name: chip_rate
  id: variable
  parameters:
    value: 1.023e6
  states: {}
- name: control_rate
  id: variable
  parameters:
    comment: Low sample rate for logic
    value: '10'
  states: {}
- name: jammer_freq_offset
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: jammer_power
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: mtti_min
  id: variable_qtgui_range
  parameters:
    comment: Time to initiate attack
    label: MTTI (Minutes)
    start: '0.01'
    step: '0.01'
    stop: '200'
    value: '100'
  states: {}
- name: mttr_min
  id: variable_qtgui_range
  parameters:
    comment: Recovery time
    label: MTTR (Minutes)
    start: '0.01'
    step: '0.01'
    stop: '20'
    value: '2'
  states: {}
- name: on_time_min
  id: variable
  parameters:
    value: mttr_min
  states: {}
- name: period_total_min
  id: variable
  parameters:
    value: mtti_min + mttr_min
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    type: complex
  states: {}
- name: control_sawtooth
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Generates slow ramp
    freq: 1.0 / (period_total_min * 60.0)
    offset: '0'
    phase: '0'
    samp_rate: control_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: decimate_clean
  id: blocks_keep_one_in_n
  parameters:
    n: int(sample_rate / 10)
    type: float
  states: {}
- name: decimate_jammed
  id: blocks_keep_one_in_n
  parameters:
    n: int(sample_rate / 10)
    type: float
  states: {}
- name: file_clean
  id: blocks_file_sink
  parameters:
    file: signal_propre.bin
    type: float
    unbuffered: 'True'
  states: {}
- name: file_jammed
  id: blocks_file_sink
  parameters:
    file: signal_brouille.bin
    type: float
    unbuffered: 'True'
  states: {}
- name: float_to_complex
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: interpolator
  id: blocks_repeat
  parameters:
    comment: Upscale logic to RF
    interp: int(sample_rate / control_rate)
    type: float
  states: {}
- name: mag_sq_clean
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: mag_sq_jammed
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: mixer
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: on_off_switch
  id: blocks_multiply_xx
  parameters:
    comment: Multiplies RF by Time Control
    type: complex
  states: {}
- name: power_scale
  id: blocks_multiply_const_vxx
  parameters:
    const: jammer_power
    type: complex
  states: {}
- name: rf_source
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: jammer_freq_offset
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: time_slicer
  id: blocks_threshold_ff
  parameters:
    comment: Output 1 only during the top fraction
    high: 1.0 - (2.0 * (on_time_min / period_total_min)) + 0.01
    init: '0'
    low: 1.0 - (2.0 * (on_time_min / period_total_min)) - 0.01
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:5556
    hwm: '0'
    timeout: '100'
    type: complex
    vlen: '2'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5555
    alias: zeromq_sub_source
    hwm: '0'
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', zeromq_pub_sink_0, '0']
- [control_sawtooth, '0', time_slicer, '0']
- [decimate_clean, '0', file_clean, '0']
- [decimate_jammed, '0', file_jammed, '0']
- [float_to_complex, '0', on_off_switch, '1']
- [interpolator, '0', float_to_complex, '0']
- [mag_sq_clean, '0', decimate_clean, '0']
- [mag_sq_jammed, '0', decimate_jammed, '0']
- [mixer, '0', blocks_stream_to_vector_0, '0']
- [mixer, '0', mag_sq_jammed, '0']
- [on_off_switch, '0', power_scale, '0']
- [power_scale, '0', mixer, '1']
- [rf_source, '0', on_off_switch, '0']
- [time_slicer, '0', interpolator, '0']
- [zeromq_sub_source_0, '0', mag_sq_clean, '0']
- [zeromq_sub_source_0, '0', mixer, '0']

metadata:
  file_format: 1
