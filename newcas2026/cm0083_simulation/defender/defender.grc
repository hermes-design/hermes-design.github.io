options:
  parameters:
    generate_options: qt_gui
    id: defender_spatial_recorded
    output_language: python
    title: Defender Recorded (Repair Rate Test)
  states: {}

blocks:
- name: control_rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: mtid_min
  id: variable
  parameters:
    comment: 'Mean Time to Initiate Defense: 1/10'
    value: 1.0/10.0
  states: {}
- name: mttr_def_min
  id: variable
  parameters:
    comment: 'Recovery Time: 1/2'
    value: 1.0/2.0
  states: {}
- name: null_angle
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Nulling Angle (Deg)
    start: '-90'
    step: '1'
    stop: '90'
    value: '0'
  states: {}
- name: null_weight
  id: variable
  parameters:
    value: cmath.exp(-1j * math.pi * math.sin(math.radians(null_angle)))
  states: {}
- name: period_total_min
  id: variable
  parameters:
    value: mtid_min + mttr_def_min
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: apply_switch
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: apply_weight
  id: blocks_multiply_const_vxx
  parameters:
    const: null_weight
    type: complex
  states: {}
- name: defense_cycle
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: 1.0 / (period_total_min * 60.0)
    offset: '0.5'
    phase: '0'
    samp_rate: control_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: defense_switch
  id: blocks_threshold_ff
  parameters:
    high: (mtid_min / period_total_min) + 0.01
    init: '0'
    low: (mtid_min / period_total_min) - 0.01
  states: {}
- name: file_defended_power
  id: blocks_file_sink
  parameters:
    file: defended_power.bin
    type: float
    unbuffered: 'True'
  states: {}
- name: float_to_complex
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math, cmath
  states: {}
- name: interpolator
  id: blocks_repeat
  parameters:
    interp: int(samp_rate / control_rate)
    type: float
  states: {}
- name: mag_sq_defended
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: Signal Brut
    label2: Signal Nettoye
    name: '"Efficacite du Nulling"'
    nconnections: '2'
    type: complex
  states: {}
- name: split_antennas
  id: blocks_vector_to_streams
  parameters:
    type: complex
  states: {}
- name: subtractor
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: zeromq_sub_source
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
    type: complex
    vlen: '2'
  states: {}

connections:
- [apply_switch, '0', subtractor, '1']
- [apply_weight, '0', apply_switch, '0']
- [defense_cycle, '0', defense_switch, '0']
- [defense_switch, '0', interpolator, '0']
- [float_to_complex, '0', apply_switch, '1']
- [interpolator, '0', float_to_complex, '0']
- [mag_sq_defended, '0', file_defended_power, '0']
- [split_antennas, '0', qtgui_freq_sink_x_0, '0']
- [split_antennas, '0', subtractor, '0']
- [split_antennas, '1', apply_weight, '0']
- [subtractor, '0', mag_sq_defended, '0']
- [subtractor, '0', qtgui_freq_sink_x_0, '1']
- [zeromq_sub_source, '0', split_antennas, '0']

metadata:
  file_format: 1
