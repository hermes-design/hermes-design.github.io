options:
  parameters:
    generate_options: no_gui
    id: defender_spatial_recorded
    output_language: python
    title: Defender Recorded (Repair Rate Test)
  states: {}

blocks:
- name: delta_phi
  id: variable
  parameters:
    value: math.pi * math.sin(math.radians(jam_angle))
  states: {}
- name: jam_angle
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1023000'
  states: {}
- name: w1_i
  id: variable
  parameters:
    value: '0'
  states: {}
- name: w1_r
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: w2_i
  id: variable
  parameters:
    value: '0'
  states: {}
- name: w2_r
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: complex(w1_r, w1_i)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: complex(w2_r, w2_i)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: cmath.exp(1j * delta_phi)
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: digital.qpsk_constellation()
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    berminerrors: '10000'
    test_mode: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math, cmath
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: '16'
    frame_rate: '30'
    ref_scale: '2'
    sample_rate: samp_rate
    shift: 'False'
    type: complex
  states: {}
- name: probe_ber
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_psd
  id: blocks_probe_signal_vx
  parameters:
    type: float
    vlen: '16'
  states: {}
- name: probe_rssi
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Antenna 2 - Phase-Shifted Input
    name: Antenna 2 - Phase-Shifted Input
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Galileo Satellite + Jammer
    name: Antenna 1 - Raw Contaminated Input
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Restored Galileo Signal
    name: Defended Receiver Output (Z(t))
    type: complex
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.01'
    type: float
  states: {}
- name: zeromq_sub_source
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5555
    alias: Satelitte
    comment: Satelitte
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5556
    alias: Attacker
    comment: Attacker
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_1
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5557
    alias: Satelitte_def
    comment: Satelitte
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_1, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_add_xx_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_1, '0', logpwrfft_x_0, '0']
- [blocks_add_xx_1, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_sub_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_const_vxx_2, '0', blocks_add_xx_0, '1']
- [blocks_sub_xx_0, '0', blocks_null_sink_0, '0']
- [blocks_sub_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_sub_xx_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', fec_ber_bf_0, '1']
- [fec_ber_bf_0, '0', probe_ber, '0']
- [logpwrfft_x_0, '0', probe_psd, '0']
- [single_pole_iir_filter_xx_0, '0', probe_rssi, '0']
- [zeromq_sub_source, '0', blocks_add_xx_0, '0']
- [zeromq_sub_source, '0', blocks_add_xx_1, '0']
- [zeromq_sub_source_0, '0', blocks_add_xx_1, '1']
- [zeromq_sub_source_0, '0', blocks_multiply_const_vxx_2, '0']
- [zeromq_sub_source_1, '0', fec_ber_bf_0, '0']

metadata:
  file_format: 1
