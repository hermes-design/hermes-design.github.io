options:
  parameters:
    generate_options: no_gui
    id: defender_spatial_recorded
    output_language: python
    title: Defender Recorded (Repair Rate Test)
  states: {}

blocks:
- name: delta_phi
  id: variable
  parameters:
    value: math.pi * math.sin(math.radians(jam_angle))
  states: {}
- name: jam_angle
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rssi_alpha
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1023000'
  states: {}
- name: w1_i
  id: variable
  parameters:
    value: '0'
  states: {}
- name: w1_r
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: w2_i
  id: variable
  parameters:
    value: '0'
  states: {}
- name: w2_r
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_add_out
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_sum
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_x1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_x2
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: complex(w1_r, w1_i)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: complex(w2_r, w2_i)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: cmath.exp(1j * delta_phi)
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: digital.qpsk_constellation()
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    berminerrors: '10000'
    test_mode: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math, cmath
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: '16'
    frame_rate: '30'
    ref_scale: '2'
    sample_rate: samp_rate
    shift: 'False'
    type: complex
  states: {}
- name: probe_ber
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_psd
  id: blocks_probe_signal_vx
  parameters:
    type: float
    vlen: '16'
  states: {}
- name: probe_rssi
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_sinr_jam
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_sinr_sig
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: rssi_alpha
    type: float
  states: {}
- name: sinr_jam_add
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: sinr_jam_iir
  id: single_pole_iir_filter_xx
  parameters:
    alpha: rssi_alpha
    type: float
  states: {}
- name: sinr_jam_mag2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: sinr_jam_phase
  id: blocks_multiply_const_vxx
  parameters:
    const: cmath.exp(1j * delta_phi)
    type: complex
  states: {}
- name: sinr_jam_w1
  id: blocks_multiply_const_vxx
  parameters:
    const: complex(w1_r, w1_i)
    type: complex
  states: {}
- name: sinr_jam_w2
  id: blocks_multiply_const_vxx
  parameters:
    const: complex(w2_r, w2_i)
    type: complex
  states: {}
- name: sinr_sig_add
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: sinr_sig_iir
  id: single_pole_iir_filter_xx
  parameters:
    alpha: rssi_alpha
    type: float
  states: {}
- name: sinr_sig_mag2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: sinr_sig_w1
  id: blocks_multiply_const_vxx
  parameters:
    const: complex(w1_r, w1_i)
    type: complex
  states: {}
- name: sinr_sig_w2
  id: blocks_multiply_const_vxx
  parameters:
    const: complex(w2_r, w2_i)
    type: complex
  states: {}
- name: snippet_sinr
  id: snippet
  parameters:
    code: def get_measured_sinr_db(self):\n    import math\n    p_sig = self.probe_sinr_sig.level()\n    p_jam = self.probe_sinr_jam.level()\n    eps = 1e-20\n    return 10.0 * math.log10((p_sig + eps) / (p_jam + eps))\ntype(self).get_measured_sinr_db = get_measured_sinr_db\n
    section: main_after_init
  states: {}
- name: zeromq_sub_source
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5555
    alias: Satelitte
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5556
    alias: Attacker
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_1
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5557
    alias: Satelitte_def
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_add_out, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_add_sum, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_add_sum, '0', logpwrfft_x_0, '0']
- [blocks_add_x1, '0', blocks_add_sum, '0']
- [blocks_add_x1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_x2, '0', blocks_add_sum, '1']
- [blocks_add_x2, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_out, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_out, '1']
- [blocks_multiply_const_vxx_2, '0', blocks_add_x2, '1']
- [digital_constellation_decoder_cb_0, '0', fec_ber_bf_0, '1']
- [fec_ber_bf_0, '0', probe_ber, '0']
- [logpwrfft_x_0, '0', probe_psd, '0']
- [single_pole_iir_filter_xx_0, '0', probe_rssi, '0']
- [sinr_jam_add, '0', sinr_jam_mag2, '0']
- [sinr_jam_iir, '0', probe_sinr_jam, '0']
- [sinr_jam_mag2, '0', sinr_jam_iir, '0']
- [sinr_jam_phase, '0', sinr_jam_w2, '0']
- [sinr_jam_w1, '0', sinr_jam_add, '0']
- [sinr_jam_w2, '0', sinr_jam_add, '1']
- [sinr_sig_add, '0', sinr_sig_mag2, '0']
- [sinr_sig_iir, '0', probe_sinr_sig, '0']
- [sinr_sig_mag2, '0', sinr_sig_iir, '0']
- [sinr_sig_w1, '0', sinr_sig_add, '0']
- [sinr_sig_w2, '0', sinr_sig_add, '1']
- [zeromq_sub_source, '0', blocks_add_x1, '0']
- [zeromq_sub_source, '0', blocks_add_x2, '0']
- [zeromq_sub_source, '0', sinr_sig_w1, '0']
- [zeromq_sub_source, '0', sinr_sig_w2, '0']
- [zeromq_sub_source_0, '0', blocks_add_x1, '1']
- [zeromq_sub_source_0, '0', blocks_multiply_const_vxx_2, '0']
- [zeromq_sub_source_0, '0', sinr_jam_phase, '0']
- [zeromq_sub_source_0, '0', sinr_jam_w1, '0']
- [zeromq_sub_source_1, '0', fec_ber_bf_0, '0']

metadata:
  file_format: 1
